# Repository mavka/CalmaAcc

File README.md:

# CalmaAcc
Calma with accelerometer

## KiCad design CalmaAcc_hw/CalmaAcc.kicad_pcb

Parts:
B1: BAT; BAT_CH7410
C1, C6: 4.7u; CAP_0402
C2, C3, C7: 0.1u; CAP_0402
C4: 1u; CAP_0402
C5: 10n; CAP_0402
C9, C10: 47u; CAP_0805
D1, D3, D4: LED; LED_0603
D2: BAT54WS; SOD323
DD1: MMA8452Q; QFN16_5_3
DD2: STM32F042F6P6; TSSOP20
Q1: MMBT2222; SOT23-3
R1, R2: 4k7; RES_0402
R3, R5, R6: 100R; RES_0402
R4: 1k; RES_0402
XL1: ST_SWD; PLS-4
XL3: CONN_2; PLS-2
XL4: CONN_3; PLS-3

Connections:
+BATT: B1.A, C1.1, C2.1, C4.1, C5.1, C6.1, C7.1, C9.1, C10.1, D2.C, DD1.1 (VDDIO), DD1.14 (VDD), DD2.5, DD2.16, R1.2, R2.2, XL1.1 (Vdd), XL3.1
/ACC_INT1: DD1.11 (INT1), DD2.6
/I2C_SCL: DD1.4 (SCL), DD2.3, R1.1
/I2C_SDA: DD1.6 (SDA), DD2.2, R2.1
/SWCLK: DD2.20, XL1.2 (SWCLK)
/SWDIO: DD2.19, XL1.4 (SWDIO)
/UART_RX: DD2.9, XL4.3
/UART_TX: DD2.8, XL4.2 (PM)
/Vibro: DD2.10, R4.2
/Vibro_out: D2.A, Q1.3 (C), XL3.2 (PM)
GND: B1.C, C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C10.2, D1.C, D3.C, D4.C, DD1.5 (GND), DD1.7 (SA0), DD1.10 (GND), DD1.12 (GND), DD2.15, Q1.2 (E), XL1.3 (GND), XL4.1
unnamed: C3.1, DD1.2 (BYP)
unnamed: D1.A, R3.2
unnamed: D3.A, R5.1
unnamed: D4.A, R6.1
unnamed: DD2.12, R5.2
unnamed: DD2.13, R6.2
unnamed: DD2.14, R3.1
unnamed: Q1.1 (B), R4.1

Notes on the sheet:
Programming
Debug port
Accelerometer
Vibro

Board: 2 copper layers, 27.0 x 17.0 mm, 26 parts (1 on the bottom side), 19 nets.

## Code that names these connections

File CalmaAcc_fw/board.h:

/*
 * board.h
 *
 *  Created on: 12 ñåíò. 2015 ã.
 *      Author: Kreyl
 */

#ifndef BOARD_H_
#define BOARD_H_

#include <inttypes.h>

// ==== General ====
#define BOARD_NAME          "AccCalma"
// MCU type as defined in the ST header.
//#define STM32F042x6

#define CRYSTAL_FREQ_HZ     12000000    // Freq of external crystal

// USB
//#define USBDrv      	USBD1   // USB driver to use

#if 1 // ========================== GPIO =======================================
// UART
#define UART_GPIO       GPIOA
#define UART_TX_PIN     2
#define UART_RX_PIN     3
#define UART_AF         AF1

// LEDs
#define LED0_GPIO       GPIOB
#define LED0_PIN        1
#define LED1_GPIO       GPIOA
#define LED1_PIN        7
#define LED2_GPIO       GPIOA
#define LED2_PIN        6

// Vibro
#define VIBRO_GPIO      GPIOA
#define VIBRO_PIN       4

// ACC
#define ACC_IRQ_GPIO    GPIOA
#define ACC_IRQ_PIN     0

// USB
//#define USB_GPIO		GPIOA
//#define USB_DM_PIN		11
//#define USB_DP_PIN		12
#endif

#if 1 // ========================= Timers ======================================
#define TIM_LED0        TIM3
#define TIM_LED1        TIM3
#define TIM_LED2        TIM3

#define TIMC_LED0       4
#define TIMC_LED1       1
#define TIMC_LED2       2

#define LED_TOP_VALUE   100
#endif

#if 1 // =========================== SPI =======================================

#endif

#if 1 // ========================== USART ======================================
#define UART            USART2
#define UART_TX_REG     UART->TDR
#define UART_RX_REG     UART->RDR
#define UART_RCC_ENABLE()   rccEnableUSART2(FALSE)
#endif

#if 0 // =========================== ADC =======================================
#define ADC_REQUIRED        TRUE
// Clock divider: clock is generated from the APB2
#define ADC_CLK_DIVIDER     adcDiv2 // 32MHz / 2 = 16MHz

// ADC channels: LED3, LED6
#define SNS_CHNL0           10
#define SNS_CHNL1           14

#define ADC_VREFINT_CHNL    17  // All 4xx devices. Do not change.
const uint8_t AdcChannels[] = { SNS_CHNL0, SNS_CHNL1 };
#define ADC_CHANNEL_CNT     2   // Do not use countof(AdcChannels) as preprocessor does not know what is countof => cannot check
#define ADC_SAMPLE_TIME     ast55d5Cycles
#define ADC_SAMPLE_CNT      8   // How many times to measure every channel

#define ADC_MAX_SEQ_LEN     16  // 1...16   // Const, see ref man
#define ADC_SEQ_LEN         (ADC_SAMPLE_CNT * ADC_CHANNEL_CNT)
#if (ADC_SEQ_LEN > ADC_MAX_SEQ_LEN) || (ADC_SEQ_LEN == 0)
#error "Wrong ADC channel count and sample count"
#endif
#endif

#if 1 // =========================== DMA =======================================
#define STM32_DMA_REQUIRED  TRUE
// Uart
#define UART_DMA_TX     STM32_DMA1_STREAM4
#define UART_DMA_RX     STM32_DMA1_STREAM5
#define UART_DMA_CHNL   0   // Dummy

// ADC
#if ADC_REQUIRED
/* DMA request mapped on this DMA channel only if the corresponding remapping bit is cleared in the SYSCFG_CFGR1
 * register. For more details, please refer to Section10.1.1: SYSCFG configuration register 1 (SYSCFG_CFGR1) on
 * page173 */
#define ADC_DMA         STM32_DMA1_STREAM1
#define ADC_DMA_MODE    STM32_DMA_CR_CHSEL(0) |   /* DMA2 Stream4 Channel0 */ \
                        DMA_PRIORITY_LOW | \
                        STM32_DMA_CR_MSIZE_HWORD | \
                        STM32_DMA_CR_PSIZE_HWORD | \
                        STM32_DMA_CR_MINC |       /* Memory pointer increase */ \
                        STM32_DMA_CR_DIR_P2M |    /* Direction is peripheral to memory */ \
                        STM32_DMA_CR_TCIE         /* Enable Transmission Complete IRQ */

#endif // ADC

#endif

#endif /* BOARD_H_ */

## Commit log

2015-11-14 STM32F042G4 added
2015-11-14 sch 5%
2015-11-14 + LR44 sldrt
2015-11-15 CubeMX: +motor timer
2015-11-15 + acc
2015-11-15 scheme done?
2015-11-15 scheme update
2015-11-15 + Firmware
2015-11-15 + net
2015-11-15 +pcb and toporrrrr
2015-11-15 + gerber
2015-11-19 +STM32F042F6
2015-11-19 + TSSOP20
2015-11-19 +gerber
2015-11-21 OS 3 compiled
2015-11-25 + Os ok, Uart ok
2015-11-26 No os
2015-12-05 FW without OS
2015-12-05 + Uart
2015-12-05 + Sequencer
2015-12-06 + SW I2C + Acc Ok
2015-12-07 + Seq compare
2015-12-07 Comparator ok
2015-12-08 + Sleep RC
2015-12-08 * Leds off in vibro mode RC
2015-12-08 VIbro off in steady
